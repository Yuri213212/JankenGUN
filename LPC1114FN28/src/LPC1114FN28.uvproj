# Keil uVision project LPC1114FN28.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPC1114FN28 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c misc: --library_interface=none --bss_threshold=0
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: config_LPC11xx.s main.c
